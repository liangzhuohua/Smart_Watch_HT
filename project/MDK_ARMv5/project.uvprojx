# Keil uVision project project.uvprojx, settings and files
target HT32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HT32F52352 Holtek
  pack: Holtek.HT32_DFP.1.0.61
  cpu: IROM(0x00000000-0x1FDFF) IRAM(0x20000000-0x20003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: HT32 +hex
  AfterMake: fromelf --bin -o "#L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c include: ..\;..\..\library\CMSIS\Include;..\..\library\Device\Holtek\HT32F5xxxx\Include;..\..\library\HT32F5xxxx_Driver\inc;..\..\library\HT32_USBD_Library\inc;..\..\utilities;..\Drivers;..\..\project;..\App
  asm define: USE_HT32_CHIP=4,USE_LIBCFG_RAM_SIZE=0x4000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group User
    ../: ht32f5xxxx_01_it.c main.c UART0.c USART1.c GPIO.c GPIO.h EXTI.c EXTI.h I2C0.c I2C0.h USART1.h USART0.c USART0.h I2C1.c I2C1.h
  group Config
    ./: ht32_op.s HT32F5xxxx_01_DebugSupport.ini
    ../: ht32f5xxxx_conf.h
  group CMSIS
    ../: system_ht32f5xxxx_01.c
  group MDK-ARM
    ./: startup_ht32f5xxxx_01.s
  group Retarget
    ../../library/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../utilities/: ht32_board.c
    ../../utilities/common/: i2c_eeprom.c spi_flash.c ebi_lcd.c
  group Library
    ../../library/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_wdt.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_spi.c ht32f5xxxx_i2c.c ht32f5xxxx_adc.c ht32f5xxxx_crc.c ht32f5xxxx_rtc.c ht32f5xxxx_mctm.c ht32f5xxxx_sci.c ht32f5xxxx_usbd.c ht32f5xxxx_pdma.c ht32f5xxxx_cmp.c ht32f5xxxx_ebi.c ht32f5xxxx_i2s.c
  group Drivers
    ../Drivers/: MAX30102.c MAX30102.h ATGM336H.c ATGM336H.h Air724.c Air724.h QMI8658A.c QMI8658A.h OLED.c OLED.h OLED_Font.h
  group App
    ../App/: Delay.c Delay.h AT_Manage.c AT_Manage.h Change_Code.c Change_Code.h cJSON.c cJSON.h MQTT_Analyse.c MQTT_Analyse.h algorithm.c algorithm.h IMU.c IMU.h
software components: HT32 Stack Usage Analysis:HT32 Stack Usage Analysis 1.0.0
